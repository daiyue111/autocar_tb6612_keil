# Keil uVision project autocar_tb6612.uvprojx, settings and files
target autocar_q34_clean (6210000::V6.21::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(32000000) ELITTLE
  output: autocar_q34_clean +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..;E:\mspm0_sdk_2_02_00_05\source\third_party\CMSIS\Core\Include;E:\mspm0_sdk_2_02_00_05\source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: E:\mspm0_sdk_2_02_00_05\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Source
    ../: main.c ti_msp_dl_config.c ti_msp_dl_config.h app_io.c app_io.h motor.c motor.h track.c track.h imu.c imu.h task_select.c task_select.h task1.c task1.h task2.c task2.h task3.c task3.h task4.c task4.h
    ./: startup_mspm0g350x_uvision.s
